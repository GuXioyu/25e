# Keil uVision project SeekFree_MSPM0G3519_Device_Library.uvprojx, settings and files
target SeekFree_MSPM0G3519_Device_Library (6070000::V6.7::.\ARMCLANG)
  device: MSPM0G3519 Texas Instruments
  pack: TexasInstruments.MSPM0GX51X_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x20100000,0x00010000) IROM(0x00000000,0x00080000) IROM2(0x00400000,0x00080000) XRAM(0x20200000,0x00020000) XRAM2(0x20300000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SeekFree_MSPM0G3519_Device_Library
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3519__
  c include: ..\..\libraries\sdk\third_party\CMSIS\Core\Include;..\..\libraries\sdk;..\..\libraries\sdk\ti_config;..\..\libraries\zf_common;..\..\libraries\zf_components;..\..\libraries\zf_device;..\..\libraries\zf_driver;..\user\inc;..\code
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x80000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x20300000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20100000 size 0x10000
  scatter file: .\mspm0g3519.sct
  group user
    ../user/src/: main.c isr.c
    ../user/inc/: isr.h
    ../code/: 新建文本文档.txt
  group zf_common
    ../../libraries/zf_common/: zf_common_clock.c zf_common_clock.h zf_common_debug.c zf_common_debug.h zf_common_fifo.c zf_common_fifo.h zf_common_font.c zf_common_font.h zf_common_function.c zf_common_function.h zf_common_headfile.h zf_common_interrupt.c zf_common_interrupt.h zf_common_typedef.h
  group zf_components
    ../../libraries/zf_components/: seekfree_assistant.c seekfree_assistant.h seekfree_assistant_interface.c seekfree_assistant_interface.h
  group zf_driver
    ../../libraries/zf_driver/: zf_driver_adc.c zf_driver_adc.h zf_driver_delay.c zf_driver_delay.h zf_driver_exti.c zf_driver_exti.h zf_driver_gpio.c zf_driver_gpio.h zf_driver_pit.c zf_driver_pit.h zf_driver_pwm.c zf_driver_pwm.h zf_driver_soft_iic.c zf_driver_soft_iic.h zf_driver_spi.c zf_driver_spi.h zf_driver_timer.c zf_driver_timer.h zf_driver_uart.c zf_driver_uart.h zf_driver_flash.c zf_driver_flash.h zf_driver_encoder.c zf_driver_encoder.h
  group zf_device
    ../../libraries/zf_device/: zf_device_absolute_encoder.c zf_device_absolute_encoder.h zf_device_config.h zf_device_config.lib zf_device_dl1a.c zf_device_dl1a.h zf_device_dl1b.c zf_device_dl1b.h zf_device_imu660ra.c zf_device_imu660ra.h zf_device_imu660rb.c zf_device_imu660rb.h zf_device_imu660rc.c zf_device_imu660rc.h zf_device_imu963ra.c zf_device_imu963ra.h zf_device_ips114.c zf_device_ips114.h zf_device_ips200.c zf_device_ips200.h zf_device_ips200pro.c zf_device_ips200pro.h zf_device_tft180.c zf_device_tft180.h zf_device_tsl1401.c zf_device_tsl1401.h zf_device_type.c zf_device_type.h zf_device_wifi_spi.c zf_device_wifi_spi.h zf_device_wifi_uart.c zf_device_wifi_uart.h zf_device_wireless_uart.c zf_device_wireless_uart.h zf_device_key.c zf_device_key.h zf_device_oled.c zf_device_oled.h zf_device_gs08ra.c zf_device_gs08ra.h
  group ti_config
    ../../libraries/sdk/ti_config/: ti_msp_dl_config.c ti_msp_dl_config.h startup_mspm0g351x_uvision.s
  group Driverlib
    ../../libraries/sdk/ti/driverlib/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_comp.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_gpamp.c dl_gpio.c dl_i2c.c dl_iwdt.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc.c dl_rtc_a.c dl_rtc_b.c dl_rtc_common.c dl_scratchpad.c dl_spi.c dl_tamperio.c dl_timer.c dl_timera.c dl_timerg.c dl_trng.c dl_uart.c dl_vref.c dl_wwdt.c
    ../../libraries/sdk/ti/driverlib/m0p/sysctl/: dl_sysctl_mspm0gx51x.c
    ../../libraries/sdk/ti/driverlib/m0p/: dl_factoryregion.c
  group doc
    ../../libraries/doc/: version.txt
  group code
    ../code/: Emm_V5.c Emm_V5.h GraySensor.c GraySensor.h HWT101.c HWT101.h Motor.c Motor.h My_Flash.c My_Flash.h My_Timer.c My_Timer.h My_Uart.c My_Uart.h My_Uart_Rx.c My_Uart_Rx.h OLED.c OLED.h OLED_Data.c OLED_Data.h PID.c PID.h Task.c Task.h Line.c Line.h Gimbal.c Gimbal.h 新建文本文档.txt
